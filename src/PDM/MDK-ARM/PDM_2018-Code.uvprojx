# Keil uVision project PDM_2018-Code.uvprojx, settings and files
target PDM_2018-Code (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F302R8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PDM_2018-Code +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F302x8
  c include: ../Inc;                      ../Drivers/STM32F3xx_HAL_Driver/Inc;                      ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;                      ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;                      ../Drivers/CMSIS/Include;                      ../STM32-CAN-Code
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F3xx/Include/: stm32f302x8.h
    ..//Src/: system_stm32f3xx.c
  group Application/User
    ../Src/: CAN.c ErrorHandling.c GPIO.c Timers.c DMA.c SharedErrorHandling.c CurrentSense.c FaultHandling.c main.c stm32f3xx_it.c stm32f3xx_hal_msp.c
    ../STM32-CAN-Code/: SharedCAN.c
  group Application/Headers
    ../Inc/: CAN.h Debug.h DMA.h ErrorHandling.h gpio.h main.h SharedErrorHandling.h stm32f3xx_hal_conf.h stm32f3xx_it.h Timers.h
    ../STM32-CAN-Code/: CANDefinitions.h SharedCAN.h
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f302x8.s
software components: CMSIS:CORE 5.0.2
