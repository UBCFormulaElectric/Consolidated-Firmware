# Keil uVision project PDM.uvprojx, settings and files
target PDM (6100001::V6.10.1::.\ARMCLANG)
  device: STM32F302R8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: PDM
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F302x8, PDM, ARM_MATH_CM4
  c include: ../Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include;..\..\shared\STM32-CAN-Code\Inc;..\..\shared\GPIO\Inc;..\..\shared;..\..\shared\Heartbeat\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f302x8.s
  group Application/User
    ../Src/: Can.c CurrentSense.c Adc.c FaultHandling.c Gpio.c Timers.c main.c stm32f3xx_it.c stm32f3xx_hal_msp.c ErrorHandling.c Heartbeat.c
    ../../shared/STM32-CAN-Code/Src/: SharedCan.c
    ../../shared/GPIO/Src/: SharedGpio.c
    ../../: CMakeCache.txt
    ../../shared/Heartbeat/Src/: SharedHeartbeat.c
  group Application/Headers
    ../Inc/: Can.h CurrentSense.h Adc.h FaultHandling.h Gpio.h main.h stm32f3xx_hal_conf.h stm32f3xx_it.h Timers.h ErrorHandling.h
    ../../shared/STM32-CAN-Code/Inc/: CanDefinitions.h SharedCan.h
    ../../shared/GPIO/Inc/: SharedGpio.h
    ../../shared/Heartbeat/Inc/: SharedHeartbeat.h
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f3xx.c
software components: CMSIS:CORE 5.1.2
